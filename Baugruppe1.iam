# Autodesk Inventor assembly: Baugruppe1
## iProperties
Created: 2010-04
Part Number: Baugruppe1
Document SubType Name: Assembly
Designer: user
Surface Area: 128.5 cm^2
Volume: 25 cm^3
Author: user
